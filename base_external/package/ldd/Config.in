## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
	help
	  Supports building and installing scull module, and the misc-modules into root fs.
```
